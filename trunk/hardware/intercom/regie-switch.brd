# Repository mirdej/tvtools (continued)

## EAGLE design hardware/intercom/regie-supply2.brd

Parts:
GND: SE14
N-SUPPLY: SE14
P-SWITCHED: SE14
U$1, U$2: 418-CFM05S050
X1: 22-23-2031

Connections:
+5V: U$1.+VO (V+), X1.3
GND: GND.MP, U$1.-VO (V-), U$2.+VO (V+), X1.2
unnamed: U$2.-VO (V-), X1.1
unnamed: N-SUPPLY.MP, U$1.ACN (N), U$2.ACN (N)
unnamed: P-SWITCHED.MP, U$1.ACL, U$2.ACL

Board: 2 copper layers, 100.0 x 80.0 mm, 6 parts (0 on the bottom side), 5 nets.

## EAGLE design hardware/intercom/regie-bus.brd

Board: 2 copper layers, 119.7 x 63.2 mm, 5 parts (0 on the bottom side), 9 nets.

Parts:
U$1, U$2, U$3, U$4, U$5: MOLEX-52207-1285; 52207-1285

Connections:
+5V: U$1.P$6, U$2.P$6, U$3.P$6, U$4.P$6, U$5.P$7
-5V: U$1.P$9, U$2.P$9, U$3.P$9, U$4.P$9, U$5.P$4
DATA+: U$1.P$5, U$2.P$5, U$3.P$5, U$4.P$5, U$5.P$8
DATA-: U$1.P$4, U$2.P$4, U$3.P$4, U$4.P$4, U$5.P$9
GND: U$1.P$3, U$1.P$12, U$2.P$3, U$2.P$12, U$3.P$3, U$3.P$12, U$4.P$3, U$4.P$12, U$5.P$1, U$5.P$10
HP+: U$1.P$8, U$2.P$8, U$3.P$8, U$4.P$8, U$5.P$5
HP-: U$1.P$7, U$2.P$7, U$3.P$7, U$4.P$7, U$5.P$6
MIC+: U$1.P$11, U$2.P$11, U$3.P$11, U$4.P$11, U$5.P$2
MIC-: U$1.P$10, U$2.P$10, U$3.P$10, U$4.P$10, U$5.P$3

## EAGLE design hardware/intercom/regie-channel.brd

Board: 2 copper layers, 103.8 x 80.0 mm, 19 parts (3 on the bottom side), 21 nets.

Parts:
C1: C0603
C8, C11: C1206
C19, C20: 100n; C0603
EQ: 500; RTRIM64Y
GAIN: 500; RTRIM64Y
IC7: LM833D; SO08
JP3: 1X02
R3, R22: 50; R1206
R27, R53, R54: 75; R1206
R31, R35: 4k7; R1206
U$1: NE8FBH
U$2: MOLEX-52207-1285; 52207-1285
U$3: EL5175; SO08

Connections:
+5V: C11.1, C19.2, IC7.8, U$2.P$7, U$3.6
-5V: C8.1, C20.2, IC7.4, U$2.P$4, U$3.7
GND: C1.1, C8.2, C11.2, C19.1, C20.1, EQ.1, JP3.2, R3.2, R22.2, U$1.P$9, U$2.P$1, U$2.P$10, U$3.4, U$3.5
unnamed: R31.1, U$2.P$2
unnamed: R35.1, U$2.P$3
unnamed: R22.1, U$1.P$7, U$3.2
unnamed: C1.2, EQ.2
unnamed: R53.1, U$1.P$3
unnamed: R54.1, U$1.P$6
unnamed: GAIN.2, GAIN.3, R27.2, U$3.8
unnamed: EQ.3, GAIN.1, U$3.1
unnamed: R3.1, U$1.P$8, U$3.3
unnamed: JP3.1, R27.1
unnamed: R31.2, U$1.P$1
unnamed: R35.2, U$1.P$2
unnamed: IC7.3, U$2.P$5
unnamed: IC7.5, U$2.P$6
unnamed: U$1.P$4, U$2.P$8
unnamed: U$1.P$5, U$2.P$9
unnamed: IC7.1, IC7.2, R53.2
unnamed: IC7.6, IC7.7, R54.2

## EAGLE design hardware/intercom/node-rj45-board.brd

Parts:
HP: 22-23-2021; MPN 22-23-2021
MIC: 22-23-2021; MPN 22-23-2021
SERIAL: 22-23-2021; MPN 22-23-2021
U$1: NE8FBH
VIDEO: 22-23-2021

Connections:
GND: U$1.P$9
unnamed: MIC.2, U$1.P$1 (1)
unnamed: MIC.1, U$1.P$2 (2)
unnamed: SERIAL.2, U$1.P$4 (4)
unnamed: HP.2, U$1.P$3 (3)
unnamed: SERIAL.1, U$1.P$5 (5)
unnamed: HP.1, U$1.P$6 (6)
VIDEO+: U$1.P$7 (7), VIDEO.2
VIDEO-: U$1.P$8 (8), VIDEO.1

Board: 2 copper layers, 117.8 x 26.7 mm, 5 parts (5 on the bottom side), 8 nets.

## Commit log

2010-02-12 Initial directory structure.
2010-02-12 initial import - version for ichTV february 2009
2010-02-13 launchpad: added reload button
2010-02-13 added first version of tv light control patch
2010-02-13 made launchpad and lights talk to each other.
2010-05-27 Making a new dir for hardware
2010-05-27 Making a new dir for Editing Amp Hardware
2010-05-27 initial commit of first experimental edit amp boards
2010-05-27 headphone amp with pot between amp and phones
2010-05-29 usb + 4 hp aps on one board. there's hiss and volume control is strange. will redo design
2010-11-17 tv tools as of STREETV2010. cannot remember exactly what I've changed in a hurry... tv subtitler lets you save and recall names with position and size. tv.launchpad:???, tv.ligth: crahes max here
2012-01-21 added anyma surtitling system
2012-01-21 added option to log surtitles to generate srt. file
2012-01-21 added possibility to record performance and generate srt file
2012-01-21 fixed bug with dates in filenames for log and srt files
2012-01-25 added brightness control
2012-01-25 added possibility to find logest title
2012-04-23 added schematics for intercom node
2012-04-23 replaced headphone diff-amp with INA134
2012-04-24 corrections on main board, added 75176 transceiver
2012-04-24 added encloser plans. added preliminary mic preamp. mic preamp now gets poer and signal from rj45-board
2012-04-24 deleting shitty eagle backup files
2012-04-24 replaced 4k7 with 6k8 resistors
2012-04-24 correct resistor values on main board
2012-04-24 optimized routing and added mounting hole
2012-06-22 added option to hide either of the lines (for opera to hide one language) - changed reformat applescript to work with one-liners, this might break some usefulness for dual-language subtitles, removed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
2012-12-13 added speedlimit to midiinput for button debouncing
2013-01-02 first version of regie intercom node
2013-01-04 added more modules
2013-01-05 more compact version
2013-01-12 shitty version used to film the opera
2013-01-15 first version of better srt generator
2013-01-19 separate board for all audio stuff. filered phantom power. almost no hum anymore. production version?
2013-01-19 forgot a resistor on audio board. added firmware
2013-01-29 built like this, missing 20k resistor to tie down lm833 input from microphone
2013-01-29 removed eagle backup files
2013-01-29 added enclosures
2013-02-12 first version of regie channel with video out
2013-02-12 regie channel video receiver based on EL5175
2013-02-13 discovered major design error: Pairs on a Cat5e - RJ45 jack are pins 1+2 / 3+6 / 4+5 / 7+8 - not straight trough. corrected node and regie boards - todo: new hub. Now it's crystal clear why we always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
2013-02-15 for regie and node - this is the version that has been built and tested as of fev 15 2013. new regie bus with external mixer module. new audio xlr ou module for recording. Hub has to be redone to cor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
2013-04-06 added lights patch
2013-04-06 added light config files
2013-04-06 addded dimmerview
2013-05-18 first version of live stream mixer
2013-05-18 added slider to mix between live/canned. added midi control input for edirol
2013-05-18 fixed issue with spaces in path names
2013-05-23 started to add subtitle layer
2013-05-26 added subtitle layer for SchulTV. Added IP address display. Added support for remote control for stepping through presentations
2013-05-28 remote slide control correctly works when time is advanced with slider
2013-05-29 hide .fcplock and -localized folders in filmlist
2013-05-29 added feature to swap movies in filmlist
2013-05-29 added first version of remote subtitler
2013-05-30 added total time calculation
2013-06-02 added suppiort for logitech presenter remote. corrected movie frame calculation for presentation mode
2013-06-02 added live video freeze for presentatione mode
2013-06-09 version we used for schultv oberengstringen
2013-06-09 added event logging to subtitler
2013-06-09 added event logging to launchpad
2013-06-09 added fake live source for logfile faking with the master recording
2013-12-23 added experimental multiline tv-screen client for equilibre
2013-12-28 removed support for martin schicks italic titles because this interfered with font choice. added build script for standalone
2014-01-09 corrected hub. added simplified 4 channel switcher
2014-01-09 first untested version of firmware for new simplified controller
2014-01-09 selects cam 1 on power up. cleaned up code
2014-01-19 quick fix for 0s subtitles. seems to be an error in the logfile generation?
2014-04-07 making branch for tell a crime story project
2014-04-10 adjusted layout. removed unecessary parts. added mira-ipad interface. added jweb for cuesheet. added gnubswitch for editing control
2014-12-29 redesign of switch with 4053 and USB - no pcb layout yet. (could not find board from last year, cant remember why it didnt work)
2014-12-30 new board layout. adapted firmware. untested
2015-01-01 remote-titler as in volketswil. 4 lines for opera surtitles in equilibre 2014
2015-01-01 empty folder for managment system
2015-01-01 added picture snapping, session for current project, deleting of members
2015-01-01 can edit member info
2015-01-01 image cropping
2015-01-01 externals libraries needed for crop
2015-01-02 with home page
2015-01-02 changed filename
2015-01-02 refactor member list. can take new photo while cropping. new member input doesent show list
2015-01-02 added file upload
2015-01-03 inline editing of memebr info
2015-01-03 create, delete, modify groups. add camera to group by dragndrop
2015-01-03 can add cameras and members to groups. cannot remove members yet
2015-01-03 cropper now generates thumbnails
2015-01-03 can edit project field
2015-01-03 can remove member from group
2015-01-04 add name learning
2015-01-05 added badge creation
2015-01-05 first version of listederlüste
2015-01-06 liste der lüste works
2015-01-06 jobverteilung
2015-01-06 abspann, rudimentäer
2015-01-06 abspann besser
2015-01-06 changed document tittle for abspann
2015-01-06 modertorenspick
2015-01-06 ide logo when printing badges ad spick
2015-01-06 visual feedback for assigned positions
2015-01-07 corrected baud rate for tallys
2015-01-14 added ablauf
2015-01-14 simple user accounts. non logged in users can only see ablauf. go to /login to login
2015-01-14 jingle & abspann fix in ablauf
2015-01-14 nicer layout
2015-01-14 stylng
2015-01-14 styling
2015-01-14 stylng, dates in abspann
2015-01-15 added gender
2015-01-15 click on badge to only show/print this one
2015-01-15 show group names in member lst
2015-01-15 vcard generation & download
2015-01-21 verision Volketswil2014
2015-01-21 automatically generate logfiles with internal millisecond timer, starting when first clip is launched
2015-01-21 add possibility to find longest gaps
2015-01-21 more spacing for posten/lueste. correct printing of badges on card-printer
2015-01-21 small tool to get chapter list from fcpxml
2015-01-30 added usb out for old gnuswitch max external
2015-02-01 first take on digital recording projected texture
2015-02-01 added gnuswitch camera cut logging
2015-02-13 add klappentext. correct typo in header
2015-02-16 corrected spacing
2015-05-20 Migrating wiki contents from Google Code
2015-12-20 surtitler in max7
2016-02-27 add switch control over usb
2016-03-15 add fcpxml-to-markerlist
2016-04-10 fixed rounding error preventing remote control to work for cer^tain movies
2016-05-29 blackmgic does cause crash on load. has to manually cliuck open
2016-05-29 switched to me
2017-06-13 poly based movie player for instant play
2017-06-20 add missing poly instance
2017-06-20 add support for new harware conroller
2017-06-20 rewind movies when selecting another
2017-06-20 add sync flash signal. change recording filename so they get inserted at end of list
2017-06-20 max crashed. again: add sync flash signal. change recording filename so they get inserted at end of list
2017-06-28 add automatic light control over network. loopnotify
2018-05-19 version adliswil
2018-05-19 first version with 4 hdmi inputs
2018-06-14 version talks OE2018
2019-04-09 major rewrite of launchpad+regie. makes tv.launchpad obsolete
2019-04-12 Fix Mojave sort bug
2019-04-13 minor bugfixes
2019-04-13 add talkmaster and recorder
2019-04-14 completely in OpenGL
2019-04-16 bugfixes
2019-05-14 visual camera assignment
2019-05-15 begin quiz
2020-02-15 complete rework while switching to Blackmagic devices
2020-02-15 Add deck control.
2020-08-26 last version on rudy
2020-08-26 add missing directory
2020-09-08 fix ip adresses, fix remaining time error (ignore hours in timecode)
2021-04-11 fix cras on talk end
2021-04-11 add missing files
2021-04-11 add library warning
2021-04-11 add kfake cams
2021-04-11 reset setup after watching before new talk
2021-04-12 can save and load presets
2021-04-18 cameao presets
2021-04-18 fix typo
2021-04-24 status hottingen
2021-06-04 add title maxmpatches
2022-05-02 remove reference to atem-rec. change to littlefs
2022-07-13 fix connection issue. ESP2.0.4, Ethernet.h @ 2.0.1. add titler handling, change ip to 192.168.252.200
2022-08-24 switch to new dmx library
2024-05-06 stand mai 2024
2024-05-06 import blink2024 as basis for new lights
2024-05-06 cleanup
2024-05-06 Bump underscore in /management/.meteor/localBAK/build/programs/server
    Bumps [underscore](https://github.com/jashkenas/underscore) from 1.5.2 to 1.12.1.
    - [Commits](https://github.com/jashkenas/underscore/compare/1.5.2...1.12.1)
    ---
    updated-dependencies:
    - dependency-name: underscore
    dependency-type: direct:production
2024-05-06 Bump semver in /management/.meteor/localBAK/build/programs/server
    Bumps [semver](https://github.com/npm/node-semver) from 4.1.0 to 5.7.2.
    - [Release notes](https://github.com/npm/node-semver/releases)
    - [Changelog](https://github.com/npm/node-semver/blob/v5.7.2/CHANGELOG.md)
    - [Commits](https://github.com/npm/node-semver/compare/v4.1.0...v5.7.2)
    ---
    updated-dependencies:
2024-05-06 basic router
2024-05-06 Basic routing
2024-05-10 colors: basic CRUD
2024-05-10 basic functionaly but horrible design
2024-05-10 nicer
2024-05-11 try to improve webserver stability
2024-05-11 bigger buffer improves speed
2024-05-11 4K read buffer
2024-05-11 save and recall colorsets
2024-05-15 import from old eagle backp
2024-05-15 reroute for fab
2024-05-15 tv-controller reroute for fab
2024-05-28 move to lucioles hardware. dmx working.
2024-05-28 easy switching between ETH/WiFi
2024-05-29 fixture check
2024-05-29 Fixter check groups
2024-05-29 basic fixture control
2024-05-29 save and load scenes
2024-05-30 warn if unsaved changes. poll status
2024-05-30 warn unsaved changes fcxture view
2024-06-08 first week shultv OE
2024-06-08 change save handling, add autosave
2024-06-11 unsort members
2025-03-16 before move to ethernetlibrary
2025-03-18 Dübi Dienstag
2025-03-18 move to platformio
2025-03-22 change buzzers to esp-now
2025-03-25 dübi dienstag2
2025-03-26 new calibration, still acciodental triggers
2025-03-26 based on standard deviation
2025-03-26 trigger in middle
2025-03-26 use avg only on startup, then fixed polarity
2025-03-26 oops
2025-03-26 reset stats regularly
2025-04-22 new buzzer version
2025-04-22 powersaving leds
2025-04-24 new buzzers
2025-05-18 after wetzikon
2025-05-18 add max patches
2025-05-18 remove prints
2025-05-18 fix crash?
2025-05-18 playlist was crashing max
2025-05-18 buzzer channel auto update names
2025-05-19 building talk recorder
2025-05-20 clean up face cropping
2025-05-20 add facecropper script
2025-05-23 set imag rights on members
2025-05-24 happy emojis
2025-05-25 new listederlueste
2025-05-25 job order
2025-05-25 show missing
2025-05-25 importexport
2025-05-25 simplyfiy procedure
2025-05-25 faster group creation
2025-05-25 bump version
2025-05-29 nav changes
2025-05-29 talk interface. more solid screenhandling
2025-06-03 web interface
2025-06-03 fix webinterface
2025-06-04 webinterface for lights demo
2025-06-04 change backdrop colors
2025-06-19 hide assigned
2025-06-19 ignore pics
2025-06-19 more gitignore
