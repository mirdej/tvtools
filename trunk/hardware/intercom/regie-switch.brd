# Repository mirdej/tvtools

## EAGLE design trunk/hardware/intercom/regie-switch.brd

Parts:
ATMEGA88: ATMEGA88; TQFP32-08
C1, C2, C3, C4, C5, C6, C7, C9, C12, C13, C14, C15, C16: C-EUC0603; C0603
C8: 100n; C1206
C10, C11: CPOL-EUSMCB; SMC_B
C17, C18: 15p; C1206
D1, D2: ZENER-DIODESOD80C; SOD80C
D3, D4: 3.3V; SOD80C
DATA: 22-23-2021; MPN 22-23-2021
IC2: 4053D; SO16
IC5: 75176AD; D_R-PDSO-G8
IN1, IN2, IN3, IN4: 22-23-2021
ISP: PINHD-1X6; 1X06
L1: L-EUL5038P; L5038P
OUT: 22-23-2021
OUTB: 22-23-2021
Q1: 20MHz; HC49UP
R1, R2, R3, R4, R5, R6: 75; R1206
R7, R8, R9, R10: 6k8; R1206
R11: 680k; R1206
R12, R13: 22; M0805
R14: 120; M0805
R15: 1k5; M1206
R16, R17: 68; M1206
RESET: PRINTTASTER_SMD; SMD_SWITCH
U$1: LM1881SO8; SO08
U$2, U$6, U$7: MAX4392ESA; SO08
U$3: RJ451; RJ45-SHIELD3
U$4, U$5: JACK3.5_PCB; MX-387GL
X1: 22-23-2031
X2: PN61729

Connections:
-5V: C4.1, C6.2, C11.-, C14.2, C16.2, IC2.7 (VEE), U$2.4 (-5V), U$6.4 (-5V), U$7.4 (-5V), X1.1
AREF: ATMEGA88.20 (AREF)
D+: D4.C, R17.1, X2.3
D-: D3.C, R16.1, X2.2
DMX2: DATA.2, R12.2, R14.2
GND: ATMEGA88.5 (GND), ATMEGA88.21 (AGND), C1.2, C2.1, C3.2, C4.2, C5.1, C6.1, C7.2, C8.2, C9.1, C10.-, C11.+, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, D1.A, D2.A, D3.A, D4.A, IC2.6 (INH), IC2.8 (GND), IC5.5 (GND), IN1.1, IN2.1, IN3.1, IN4.1, ISP.1, OUT.1, OUTB.1, R3.1, R4.1, R5.1, R6.1, R8.1, R10.1, R11.1, RESET.BB (1), U$1.4 (GND), U$3.S1 (S), U$3.S2 (S), U$4.RING, U$5.RING, X1.2, X2.4
GREEN: ATMEGA88.10 ((AIN0)PD6), IC2.10 (B)
MISO: ATMEGA88.16 ((MISO)PB4), ISP.5
MOSI: ATMEGA88.15 ((MOSI/OC2)PB3), ISP.6, U$3.1
unnamed: ATMEGA88.2 ((XCK/T0)PD4), IC2.11 (A)
unnamed: ATMEGA88.28 ((ADC5/SCL)PC5), U$1.7 (ODD/EVEN)
unnamed: C12.1, IC2.1 (Y1), U$6.1 (OUT), U$6.2 (-IN)
unnamed: ATMEGA88.7 (XTAL1/OSC1), C17.2, Q1.1
unnamed: IC2.14 (X), U$2.3 (+IN), U$2.5 (+IN)
unnamed: R1.1, R7.2, U$2.1 (OUT)
unnamed: C8.1, R11.2, U$1.6 (R_SET)
unnamed: IN3.2, R6.2, U$7.3 (+IN)
unnamed: IN4.2, R5.2, U$7.5 (+IN)
unnamed: IN2.2, R3.2, U$6.5 (+IN)
unnamed: OUTB.2, R2.2
unnamed: OUT.2, R1.2
unnamed: R7.1, R8.2, U$2.2 (-IN)
unnamed: R2.1, R9.2, U$2.7 (OUT)
unnamed: ATMEGA88.4 (VCC), ATMEGA88.18 (AVCC), C1.1, C3.1, ISP.2, L1.2
unnamed: R9.1, R10.2, U$2.6 (-IN)
unnamed: ATMEGA88.23 ((ADC0)PC0)), U$3.8
unnamed: ATMEGA88.24 ((ADC1)PC1), U$3.7
unnamed: ATMEGA88.25 ((ADC2)PC2), U$3.6
unnamed: ATMEGA88.26 ((ADC3)PC3), U$3.5
unnamed: ATMEGA88.12 ((ICP)PB0), U$3.4
unnamed: ATMEGA88.13 ((OC1A)PB1), U$3.3
unnamed: ATMEGA88.14 ((SS/OC1B)PB2), U$3.2
unnamed: D2.C, IC5.7 (B), R13.1
unnamed: D1.C, IC5.6 (A), R12.1
unnamed: DATA.1, R13.2, R14.1
unnamed: ATMEGA88.31 ((TXD)PD1), IC5.4 (D), U$4.SLEEVE, U$5.SLEEVE
unnamed: C12.2, U$1.2 (INPUT)
unnamed: ATMEGA88.29 (RESET), ISP.3, RESET.AA (0)
unnamed: IC2.2 (Y0), U$6.6 (-IN), U$6.7 (OUT)
unnamed: IC2.5 (Z0), U$7.6 (-IN), U$7.7 (OUT)
unnamed: IC2.3 (Z1), U$7.1 (OUT), U$7.2 (-IN)
unnamed: ATMEGA88.32 ((INT0)PD2), R17.2
unnamed: IC2.4 (Z), IC2.12 (X0)
unnamed: IC2.13 (X1), IC2.15 (Y)
unnamed: ATMEGA88.8 (XTAL2/OSC2), C18.2, Q1.2
unnamed: ATMEGA88.1 ((INT1)PD3), R15.2, R16.2
unnamed: ATMEGA88.11 ((AIN1)PD7), R15.1
unnamed: IN1.2, R4.2, U$6.3 (+IN)
SCK: ATMEGA88.17 ((SCK)PB5), ISP.4
VCC: C2.2, C5.2, C7.1, C9.2, C10.+, C13.2, C15.2, IC2.16 (VCC), IC5.2 (!RE), IC5.3 (DE), IC5.8 (VCC), L1.1, U$1.8 (VCC), U$2.8 (+5V), U$4.TIP, U$5.TIP, U$6.8 (+5V), U$7.8 (+5V), X1.3
YELLOW: ATMEGA88.9 ((T1)PD5), IC2.9 (C)

Board: 2 copper layers, 101.3 x 81.6 mm, 62 parts (12 on the bottom side), 50 nets.

## EAGLE design branches/tell/hardware/intercom/node_mainboard.brd

Parts:
B1: RECTIFIER-S80; TO-269AA
C1: CPOL-EUE5-10.5; E5-10,5
C2: CPOL-EUE2.5-7; E2,5-7
C3: 10u; CT3528
C4, C5: 2u2tantal; CT6032
C6, C7, C8, C9, C11, C600: 100n; C0603
C18, C19: 10p; C1206
C601: 100n; C1206
DATA: 22-23-2021; MPN 22-23-2021
HP: 22-23-2021
IC1: MC78M05CDTG; DPACK_3
IC2: 79LXXDPAK; DPAK
IC4: ATTINY2313S2; SO20L_BIGPADS
IC5: 75176AD; D_R-PDSO-G8
IC6: EL5177; MSOP10
ISP1: PINHD-1X6; 1X06
LEDS: PINHD-1X3; 1X03
MIC: 22-23-2021
PWR: 22-23-2021; MPN 22-23-2021
Q1: CRYSTALHC49UP; HC49UP
R1: 15k; R0805
R2: 4k7; R1206
R3, R9, R10, R17, R18, R21, R22, R605: 330; R1206
R4: 6k8; R1206
R7: 120; R1206
R12: R-EU_R1206; R1206
R13, R14: 300; R1206
R601: 75; R0805
R602: 0; R1206
R603, R606: 680; R1206
R604, R607: 50; R0805
TP3: TPB2,54; B2,54
TR1: EI30-2
U$1: KCSA03
U$2, U$3: PRINTTASTER_SMD; SMD_SWITCH
VIDEO: 22-23-2021; MPN 22-23-2021
VIDEOIN: 22-23-2021; MPN 22-23-2021
X1: 22-23-2031
X2: NC5FAH

Connections:
+5V: C4.+, C8.1, C11.1, C601.1, IC1.3 (VO), IC4.20 (VCC), IC5.8 (VCC), IC6.8 (V+), ISP1.5, R4.1, R12.2, U$1.P$3 (A), U$1.P$8 (A), X1.3
-5V: C5.-, C9.2, C600.2, IC2.3 (OUT), IC6.9 (V-), X1.1
GND: C1.-, C2.+, C3.-, C4.-, C5.+, C6.2, C7.1, C8.2, C9.1, C11.2, C18.1, C19.1, C600.1, C601.2, IC1.4 (GND), IC2.1 (GND), IC4.10 (GND), IC5.5 (GND), IC6.3 (REF), IC6.4 (IN-), ISP1.6, LEDS.3, MIC.1, R1.1, R601.2, TR1.7 (4), TR1.9 (5), U$2.BB (1), U$3.BB (1), VIDEOIN.1, X1.2, X2.1, X2.5, X2.G
MISO: IC4.18 ((MISO/DO/PCI6)PB6), ISP1.2, R9.2
MOSI: IC4.17 ((MOSI/DI/SDA/PCI5)PB5), ISP1.1, R10.2
unnamed: IC6.2 (IN+), R601.1, VIDEOIN.2
unnamed: PWR.2, TR1.1
unnamed: PWR.1, TR1.5 (2)
unnamed: B1.AC1, TR1.6 (3)
unnamed: C3.+, R2.1, R4.2
unnamed: B1.+, C1.+, C6.1, IC1.1 (VI)
unnamed: MIC.2, R2.2, X2.4
unnamed: IC6.10 (OUT+), R603.2, R604.1
unnamed: IC6.6 (OUT-), R606.2, R607.1
unnamed: R607.2, VIDEO.1
unnamed: R604.2, VIDEO.2
unnamed: IC6.1 (FB+), R602.2, R603.1
unnamed: DATA.2, IC5.6 (A), R7.1
unnamed: DATA.1, IC5.7 (B), R7.2
unnamed: B1.-, C2.-, C7.2, IC2.4 (IN)
unnamed: IC4.6 ((CKOUT/XCK/INT0)PD2), IC5.2 (!RE), IC5.3 (DE), R1.2
unnamed: IC6.5 (FB-), R605.1, R606.1
unnamed: C18.2, IC4.4 (XTAL2(PA1)), Q1.2
unnamed: C19.2, IC4.5 (XTAL1(PA0)), Q1.1
unnamed: R602.1, R605.2
unnamed: IC4.2 ((RXD)PD0), IC5.1 (R)
unnamed: LEDS.1, R13.1
unnamed: HP.2, X2.3
unnamed: HP.1, X2.2
unnamed: B1.AC2, TR1.10 (6)
unnamed: LEDS.2, R14.1
unnamed: IC4.7 ((INT1)PD3), TP3.TP
unnamed: IC4.8 ((T0)PD4), U$3.AA (0)
unnamed: IC4.9 ((OC0B/T1)PD5), U$2.AA (0)
unnamed: IC4.11 ((ICP)PD6), R14.2
unnamed: IC4.16 ((OC1B/PCI4)PB4), R17.2
unnamed: IC4.15 ((OC1A/PCI3)PB3), R18.2
unnamed: IC4.14 ((OC0A/PCI2)PB2), R21.2
unnamed: IC4.13 ((AIN1/PCI1)PB1), R22.2
unnamed: IC4.12 ((AIN0/PCI0)PB0), R13.2
unnamed: R22.1, U$1.P$1 (E)
unnamed: R21.1, U$1.P$2 (D)
unnamed: R18.1, U$1.P$4 (C)
unnamed: R17.1, U$1.P$6 (B)
unnamed: R10.1, U$1.P$7 (A)
unnamed: R9.1, U$1.P$9 (F)
unnamed: R3.1, U$1.P$10 (G)
unnamed: IC4.3 ((TXD)PD1), IC5.4 (D)
RST: IC4.1 (RESET/DW/PA2), ISP1.4, R12.1
SCK: IC4.19 ((SCK/UCSK/PCI7)PB7), ISP1.3, R3.2

Board: 2 copper layers, 57 parts (12 on the bottom side), 50 nets.

## EAGLE design branches/tell/hardware/intercom/regie-intercom-node-with-video.brd

Parts:
C1, C5, C10, C101, C200, C201: 100n; C0603
C2: 47u; E2,5-5
C3: 10utantal; CT3528
C4: 10u; CT3528
C6, C7: 2u2tantal; CT3528
C9, C11, C303: 10n; C1206
C16, C36: 22u; E2-5
C35: 1u; C1206
C100: 100n; C1206
C300, C301: 1u; C0603
C302: 120p; C0603
C304: 470u; CT3528
DATA: 22-23-2021; MPN 22-23-2021
HPVOL: ALPS_RK09K111_HOHNE-FüSSE; ALPS_RK09K111
IC1: SSM2167; SO10
IC2: LM833D; SO08
IC3: INA134U; SO08
IC4: BHF3544-ATOMIZED; SO08
IC5: MAX4392; SO08
MIC-VOL: ALPS_RK09K111_HOHNE-FüSSE; ALPS_RK09K111
PUSHTOTOALK: 22-23-2021
R1, R6, R24, R206, R207: 75; R1206
R2, R8, R103, R201, R202, R203, R300: 1k; R1206
R3, R4, R5, R100, R204, R205: 6k8; R1206
R7: 3k; R1206
R101, R102: 50k; R1206
U$1: RJ451; RJ45-SHIELD3
VIDEO: 22-23-2021; MPN 22-23-2021
X2: NC5FAH
X4: 22-23-2031

Connections:
+5V: C1.2, C5.2, C6.+, C101.2, C200.2, C300.2, IC1.3 (!SHUTDOWN), IC1.10 (VDD), IC2.8 (V+), IC3.7 (V+), IC4.2 (MUTE), IC4.8 (VCC), IC5.8 (V+), R100.1, R102.1, R103.1, X4.3
-5V: C7.-, C10.2, C201.2, C301.2, IC2.4 (V-), IC3.4 (V-), IC5.4 (V-), X4.1
GND: C1.1, C2.-, C4.-, C5.1, C6.-, C7.+, C9.2, C10.1, C101.1, C200.1, C201.1, C300.1, C301.1, C303.2, HPVOL.1 (S), IC1.1 (GND), IC2.5 (+IN), IC3.1 (REF), IC4.4 (GND), IC5.5 (+IN), MIC-VOL.1 (S), R1.1, R3.2, R8.2, R203.2, U$1.S1 (S), U$1.S2 (S), VIDEO.1, X2.1, X2.5, X2.G, X4.2
HP1: C36.-, X2.3
unnamed: C304.-, HPVOL.3 (E)
unnamed: IC1.8 (RCOMP), R101.2
unnamed: R101.1, R102.2
unnamed: C2.+, IC4.6 (BIAS)
unnamed: C302.2, IC3.2 (-IN), U$1.4
unnamed: C4.+, IC1.6 (AVG_CAP)
unnamed: C302.1, IC3.3 (+IN), U$1.3
unnamed: MIC-VOL.2 (W), R201.2
unnamed: IC5.2 (-IN), R7.2, R8.1
unnamed: C9.1, IC2.3 (+IN), R201.1
unnamed: IC2.1 (OUT), R202.1, R204.2, R206.2
unnamed: IC2.6 (-IN), R204.1, R205.2
unnamed: IC2.7 (OUT), R205.1, R207.2
unnamed: R206.1, U$1.1
unnamed: R207.1, U$1.2
unnamed: C11.2, PUSHTOTOALK.1
unnamed: R1.2, R2.2, VIDEO.2
unnamed: IC2.2 (-IN), R202.2, R203.1
unnamed: C35.2, IC4.3 (I), IC4.5 (I)
unnamed: C35.1, HPVOL.2 (W)
unnamed: IC5.3 (+IN), R2.1
unnamed: IC5.1 (OUT), R4.2, R6.2, R7.1
unnamed: C303.1, C304.+, R300.2
unnamed: IC3.5 (SENSE), IC3.6 (OUT), R300.1
unnamed: IC5.6 (-IN), R4.1, R5.2
unnamed: C16.-, X2.2
unnamed: C16.+, IC4.1 (O)
unnamed: C100.2, IC1.5 (IN)
unnamed: C100.1, R3.1, R100.2, X2.4
unnamed: IC5.7 (OUT), R5.1, R24.2
unnamed: MIC-VOL.3 (E), PUSHTOTOALK.2
unnamed: DATA.1, U$1.6
unnamed: DATA.2, U$1.5
unnamed: C36.+, IC4.7 (O)
unnamed: IC1.7 (RGATE), R103.2
unnamed: C3.+, IC1.4 (BUFOUT)
unnamed: C3.-, IC1.2 (VCAIN)
unnamed: C11.1, IC1.9 (OUTPUT)
VIDEO+: R6.1, U$1.7
VIDEO-: R24.1, U$1.8

Notes on the sheet:
lp 15khz

Board: 2 copper layers, 100.0 x 80.0 mm, 56 parts (10 on the bottom side), 44 nets.

## EAGLE design hardware/intercom/regie-video-out.brd

Board: 2 copper layers, 103.8 x 80.0 mm, 35 parts (12 on the bottom side), 23 nets.

Parts:
C1, C4, C10: C0603
C2, C3, C5, C8, C9, C11: C1206
C6, C7: 2u2tantal; CT3528
EQ, EQ1, EQ2: 500; RTRIM64Y
GAIN, GAIN1, GAIN2: 500; RTRIM64Y
R1, R3, R4, R5, R7, R22: 50; R1206
R2, R6, R27: 75; R1206
U$1: NE8FBH
U$2, U$3, U$4: EL5175; SO08
X1, X6: 22-23-2031
X2, X3, X4: 22-23-2021

Connections:
+5V: C3.1, C6.+, C9.1, C11.1, U$2.6, U$3.6, U$4.6, X1.3
-5V: C2.1, C5.1, C7.-, C8.1, U$2.7, U$3.7, U$4.7, X1.1
GND: C1.1, C2.2, C3.2, C4.1, C5.2, C6.-, C7.+, C8.2, C9.2, C10.1, C11.2, EQ.1, EQ1.1, EQ2.1, R1.2, R3.2, R4.2, R5.2, R7.2, R22.2, U$1.P$9, U$2.4, U$2.5, U$3.4, U$3.5, U$4.4, U$4.5, X1.2, X2.1, X3.1, X4.1, X6.1
unnamed: R2.1, X3.2
unnamed: R1.1, U$1.P$3, U$2.2
unnamed: R22.1, U$1.P$7, U$3.2
unnamed: C1.2, EQ.2
unnamed: GAIN1.2, GAIN1.3, R2.2, U$2.8
unnamed: EQ1.3, GAIN1.1, U$2.1
unnamed: GAIN.2, GAIN.3, R27.2, U$3.8
unnamed: EQ.3, GAIN.1, U$3.1
unnamed: R3.1, U$1.P$8, U$3.3
unnamed: R4.1, U$1.P$6, U$2.3
unnamed: C4.2, EQ1.2
unnamed: R6.1, X4.2
unnamed: R5.1, U$1.P$4, U$4.2
unnamed: GAIN2.2, GAIN2.3, R6.2, U$4.8
unnamed: EQ2.3, GAIN2.1, U$4.1
unnamed: R7.1, U$1.P$5, U$4.3
unnamed: C10.2, EQ2.2
unnamed: U$1.P$2, X6.2
unnamed: U$1.P$1, X6.3
unnamed: R27.1, X2.2
