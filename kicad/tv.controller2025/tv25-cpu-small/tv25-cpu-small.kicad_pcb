# Repository mirdej/tvtools

## KiCad design kicad/tv.controller2025/tv25-cpu-small/tv25-cpu-small.kicad_pcb

Board: 2 copper layers, 36.0 x 40.0 mm, 39 parts (5 on the bottom side), 28 nets.

Parts:
C1: 100n; C_0603_1608Metric
C2: 10u; C_0805_2012Metric
C3: 4u7; C_0805_2012Metric
C4: 1u; C_0603_1608Metric
C5, C6: 10p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: RDY; LED_0805_2012Metric
D2: CHRG; LED_0805_2012Metric
D4: SK6812MINI; SK6812-MINI-HS
H1, H2, H3, H4: MountingHole; MountingHole_2.7mm_M2.5
J1: BATT; PinHeader_1x02_P2.54mm_Horizontal
J2: Conn_01x10; IDC-Header_2x05_P2.54mm_Vertical
J3: Prog; ESP-POGO-PROG-THT
J4: USB_C_Receptacle_USB2.0; JAE_USB-C_SJ122205
J11: pixels; ComboPinhead_03
JP1: cell-powered; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R2, R4, R5: 2k; R_0603_1608Metric
R3, R6, R7, R8, R9, R10, R11: 5k1; R_0603_1608Metric
SW2: Reset; SW_Push_1P1T_NO_CK_KMR2
SW3: SW_SPDT; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW4: Btn-1; DDS001
U1: MCP73831-2-OT; SOT-23-5
U2: XC6220B331MR; SOT-23-5
U3: TDFN-8-1EP_2x2mm_P0.5mm_EP0.8x1.2mm
U4: ESP32-C3-MINI-1
U5: LOGO; logo_anyma
Y1: 32.768khz; Crystal_SMD_G8-2Pin_3.2x1.5mm

Connections:
+3V3: C3.1, J2.1, J3.1, JP1.2 (B), R3.1, R6.1, R7.1, R10.1, R11.1, U2.5 (VOUT), U4.3 (3V3)
+3V8: C2.1, D4.4 (VDD), J11.1, SW3.2 (B), U2.1 (VIN), U2.3 (CE)
+5V: J4.A4 (VBUS), J4.A9 (VBUS), R4.1, U1.4 (VDD)
+BATT: C1.1, J1.2, JP1.1 (A), SW3.1 (A), U1.3 (VBAT), U3.2 (CELL), U3.3 (VDD)
/en: C4.1, J3.2, R3.2, SW2.2, U4.8 (EN/CHIP_PU)
/gpio_8: J2.8, R6.2, U4.22 (GPIO8)
/pix: D4.3 (DIN), U4.21 (GPIO7)
/pixout: D4.1 (DOUT), J2.2, J11.2
/rx: J3.4, U4.30 (GPIO20/U0RXD)
/scl/flash: J3.3, R11.2, U3.7 (SCL), U4.23 (GPIO9)
/sda: R10.2, U3.8 (SDA), U4.16 (GPIO10)
/strap2: J2.3, R7.2, SW4.1, U4.5 (GPIO2/ADC1_CH2)
/tx: J3.5, U4.31 (GPIO21/U0TXD)
/usb+: J4.A6 (D+), J4.B6 (D+), U4.27 (GPIO19/USB_D+)
/usb-: J4.A7 (D-), J4.B7 (D-), U4.26 (GPIO18/USB_D-)
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, D4.2 (VSS), J1.1, J2.10, J3.6, J4.A1 (GND), J4.A12 (GND), J4.S1 (SHIELD), J11.3, R1.2, R2.2, R5.2, R8.2, R9.2, SW2.1, SW4.2, U1.2 (VSS), U2.2 (GND), U3.1 (CTG), U3.4 (GND), U3.6 (QSTRT), U3.9 (EP), U4.1 (GND), U4.2 (GND), U4.11 (GND), U4.14 (GND), U4.36 (GND), U4.37 (GND), U4.38 (GND), U4.39 (GND), U4.40 (GND), U4.41 (GND), U4.42 (GND), U4.43 (GND), U4.44 (GND), U4.45 (GND), U4.46 (GND), U4.47 (GND), U4.48 (GND), U4.49 (GND), U4.50 (GND), U4.51 (GND), U4.52 (GND), U4.53 (GND)
unnamed: D1.2 (A), D2.1 (K), U1.1 (STAT)
unnamed: D1.1 (K), R2.1
unnamed: D2.2 (A), R4.2, R5.1
unnamed: J2.4, U4.6 (GPIO3/ADC1_CH3)
unnamed: J2.5, U4.18 (GPIO4/ADC1_CH4)
unnamed: J2.6, U4.19 (GPIO5/ADC2_CH0)
unnamed: J2.7, U4.20 (GPIO6)
unnamed: J4.A5 (CC1), R8.1
unnamed: J4.B5 (CC2), R9.1
unnamed: R1.1, U1.5 (PROG)
unnamed: C5.2, U4.12 (GPIO0/ADC1_CH0/XTAL_32K_P), Y1.2
unnamed: C6.2, U4.13 (GPIO1/ADC1_CH1/XTAL_32K_N), Y1.1

## KiCad design kicad/tv.controller2025/tv25-cpu/tv25-cpu.kicad_pcb

Parts:
C3: 100n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C5: 1u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C6: 100n; C_0603_1608Metric
C7: 10u; C_0805_2012Metric
C8: 4u7; C_0805_2012Metric
D1, D2, D3, D6: SK6812MINI; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm
D4: RDY; LED_0805_2012Metric
D5: CHRG; LED_0805_2012Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.5mm_Pad
J1, J2, J4, J5: Conn_01x10; IDC-Header_2x05_P2.54mm_Vertical
J3: USB_C_Receptacle_USB2.0; JAE_USB-C_SJ122205
J11: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J12: BATT; PinHeader_1x02_P2.54mm_Horizontal
J13: Charge; PogoChargeConn
JP1: cabled; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: vbus; SolderJumper-2_P1.3mm_Bridged2Bar_RoundedPad1.0x1.5mm
R1, R3: 5k1; R_0805_2012Metric
R2, R5: 5k1; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R7, R8: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R9, R10, R11, R12: 2k; R_0603_1608Metric
RV1, RV2: R_Potentiometer; Potentiometer_Alps_RK09K_Single_Vertical
SW1, SW3, SW4, SW5: SW_Push; SW_Tactile_SPST_NO_Straight_CK_PTS636Sx25SMTRLFS
SW2: SW_SPDT; Microschalter
U1: i2c-display128x32; Bangood_I2C_Display
U2, U7: LOGO; logo_anyma_tiny
U3: ESP32-S3-WROOM
U4: MCP73831-2-OT; SOT-23-5
U5: XC6220B331MR; SOT-23-5
U6: TDFN-8-1EP_2x2mm_P0.5mm_EP0.8x1.2mm

Connections:
+3V3: C3.1, C8.1, D1.4 (VDD), D2.4 (VDD), D3.4 (VDD), D6.4 (VDD), J1.1, J2.1, J4.1, J5.1, J11.1, R1.1, R3.1, R7.1, R8.1, RV1.3, RV2.3, U1.2 (VCC), U3.2 (VCC), U5.5 (VOUT)
+3V8: C7.1, JP1.2 (B), SW2.2 (B), U5.1 (VIN), U5.3 (CE)
+5V: J13.1, JP1.1 (A), JP2.2 (B), R11.1, U4.4 (VDD)
+BATT: C6.1, J12.2, SW2.1 (A), U4.3 (VBAT), U6.2 (CELL), U6.3 (VDD)
/b39: J5.8, SW5.1, U3.32 (39|MTCK)
/b40: J5.7, SW4.1, U3.33 (40|MTDO)
/b41: J5.6, SW3.1, U3.34 (41|MTDI)
/b42: J5.5, SW1.1, U3.35 (42|MTMS)
/en: C5.1, J11.2, R7.2, U3.3 (EN)
/flash: J11.3, R8.2, U3.27 (0)
/gpio_6: U6.5 (!ALRT)
/pix: D1.3 (DIN), U3.10 (17|U1TXD|AD2.6)
/rx: J11.4, U3.36 (44|RX)
/scl: R3.2, U1.3 (SCL), U3.31 (38)
/scl/flash: U6.7 (SCL)
/sda: R1.2, U1.4 (SDA), U3.30 (37), U6.8 (SDA)
/tx: J11.5, U3.37 (43|TX)
/usb+: J3.A6 (D+), J3.B6 (D+), U3.14 (20|U1CTS|AD2.9|USB-D+)
/usb-: J3.A7 (D-), J3.B7 (D-), U3.13 (19|U1RTS|AD2.8|USB-D-)
GND: C3.2, C5.2, C6.2, C7.2, C8.2, D1.2 (VSS), D2.2 (VSS), D3.2 (VSS), D6.2 (VSS), H1.1, H2.1, H3.1, H4.1, J1.10, J2.10, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), J4.10, J5.10, J11.6, J12.1, J13.2, R2.2, R5.2, R9.2, R10.2, R12.2, RV1.1, RV2.1, SW1.2, SW3.2, SW4.2, SW5.2, U1.1 (GND), U3.1 (GND), U3.15 (03|T3|AD1.2), U3.40 (GND), U3.41 (GND), U4.2 (VSS), U5.2 (GND), U6.1 (CTG), U6.4 (GND), U6.6 (QSTRT), U6.9 (EP)
unnamed: D1.1 (DOUT), D2.3 (DIN)
unnamed: D2.1 (DOUT), D3.3 (DIN)
unnamed: D3.1 (DOUT), D6.3 (DIN)
unnamed: D4.2 (A), D5.1 (K), U4.1 (STAT)
unnamed: D4.1 (K), R10.1
unnamed: D5.2 (A), R11.2, R12.1
unnamed: D6.1 (DOUT), J1.2
unnamed: J1.3, U3.4 (04|T4|AD1.3)
unnamed: J1.4, U3.5 (05|T5|AD1.4)
unnamed: J1.5, U3.6 (06|T6|AD1.5)
unnamed: J1.6, U3.7 (07|T7|AD1.6)
unnamed: J1.7, U3.8 (15|U0RTS|AD2.4)
unnamed: J1.8, U3.9 (16|U0CTS|AD2.5)
unnamed: J1.9, J2.2
unnamed: J2.3, U3.11 (18|U1RXD|AD2.7)
unnamed: J2.4, U3.12 (08|T8|AD1.7)
unnamed: J2.5, U3.17 (09|T09|AD1.8|FSPIHD)
unnamed: J2.6, U3.18 (10|T10|AD1.9|FPSICS0)
unnamed: J2.7, U3.19 (11|T11|AD2.0|FSPID)
unnamed: J2.8, U3.20 (12|T12|AD2.1|FSPICLK)
unnamed: J2.9, J4.2
unnamed: J3.A5 (CC1), R2.1
unnamed: J3.B5 (CC2), R5.1
unnamed: J4.3, U3.21 (13|T13|AD2.2|FSPIQ)
unnamed: J4.4, U3.22 (14|T14|AD2.C3|FSPIWP)
unnamed: J4.5, U3.23 (21)
unnamed: J4.6, U3.24 (47)
unnamed: J4.7, U3.25 (48)
unnamed: J4.8, U3.16 (46)
unnamed: J4.9, J5.2
unnamed: J5.3, RV1.2, U3.39 (01|T01|AD1.0)
unnamed: J5.4, RV2.2, U3.38 (02|T2|AD1.1)
unnamed: J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), JP2.1 (A)
unnamed: R9.1, U4.5 (PROG)

Board: 2 copper layers, 65.5 x 75.9 mm, 49 parts (9 on the bottom side), 52 nets.

## KiCad design kicad/tv.controller2025/tv25-rotary/tv25-rotary.kicad_pcb

Parts:
H1, H2, H3, H4, H5, H6, H7, H8: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x10; IDC-Header_2x05_P2.54mm_Vertical
SW7, SW8, SW9: RotaryEncoder; RotaryEncoder_Alps_EC12E_HV-Combo

Connections:
+3V3: J1.1
GND: J1.10, SW7.C, SW8.C, SW9.C
unnamed: J1.2, J1.9
unnamed: J1.3, SW7.A
unnamed: J1.4, SW7.B
unnamed: J1.5, SW8.A
unnamed: J1.6, SW8.B
unnamed: J1.7, SW9.A
unnamed: J1.8, SW9.B

Board: 2 copper layers, 176.5 x 35.6 mm, 12 parts (1 on the bottom side), 8 nets.

## KiCad design kicad/tv.controller2025/tv25-tbar/tv25-tbar.kicad_pcb

Parts:
C1, C2: C; C_0603_1608Metric
D1, D2, D3, D4, D5, D6: SK6812MINI; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x10; IDC-Header_2x05_P2.54mm_Vertical
RV1: tbar; Potentiometer_Alps_RK09K_Single_Horizontal
RV2: pot; Potentiometer_Alps_RK09K_Single_Vertical
RV3: slider; Potentiometer_Alps_RS6011xP_Slide
SW1, SW2, SW3, SW4: SW_Push; SW_Tactile_SPST_NO_Straight_CK_PTS636Sx25SMTRLFS

Connections:
+3V3: C1.1, C2.1, D1.4 (VDD), D2.4 (VDD), D3.4 (VDD), D4.4 (VDD), D5.4 (VDD), D6.4 (VDD), J1.1, RV1.3, RV2.3, RV3.3
GND: C1.2, C2.2, D1.2 (VSS), D2.2 (VSS), D3.2 (VSS), D4.2 (VSS), D5.2 (VSS), D6.2 (VSS), J1.10, RV1.1, RV2.1, RV3.1, SW1.2, SW2.2, SW3.2, SW4.2
unnamed: D1.3 (DIN), J1.2
unnamed: D1.1 (DOUT), D2.3 (DIN)
unnamed: D2.1 (DOUT), D3.3 (DIN)
unnamed: D3.1 (DOUT), D4.3 (DIN)
unnamed: D4.1 (DOUT), D5.3 (DIN)
unnamed: D5.1 (DOUT), D6.3 (DIN)
unnamed: D6.1 (DOUT), J1.9
unnamed: J1.3, SW1.1
unnamed: J1.4, SW2.1
unnamed: J1.5, SW3.1
unnamed: J1.6, SW4.1
unnamed: J1.7, RV1.2, RV3.2
unnamed: J1.8, RV2.2

Board: 2 copper layers, 60.0 x 80.0 mm, 22 parts (1 on the bottom side), 15 nets.

## KiCad design kicad/biuzzcharge/biuzzcharge.kicad_pcb

Parts:
H1, H2: MountingHole; MountingHole_3.2mm_M3
J1: BATT; PinHeader_1x02_P2.54mm_Horizontal
J2: Charge; PogoChargeConn

Connections:
+5V: J1.2, J2.1
GND: J1.1, J2.2

Board: 2 copper layers, 4 parts (1 on the bottom side), 2 nets, no tracks yet.

## KiCad design kicad/tv.controller2023/tv.controller2023.kicad_pcb

Board: 2 copper layers, 146.3 x 43.7 mm, 29 parts (0 on the bottom side), 27 nets.

Parts:
C1: 10u; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C2: 1u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8: SK6812MINI; SK6812-MINI-HS
H1, H2: MountingHole_Pad; MountingHole_2.5mm_Pad
J1: USB_C_Receptacle_USB2.0; JAE_USB-C_SJ122205
J2: Conn_01x06; ComboPinhead_06
R1, R2: 5k1; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3, R4: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RV1, RV2: R_Potentiometer; Potentiometer_Alps_RK09K_Single_Vertical
SW1, SW2, SW3, SW4, SW5, SW6: SW_Push; Alps_Tactile_Switch
SW7: RotaryEncoder; RotaryEncoder_Alps_EC12E_Vertical_H20mm
U1: AZ1117-3.3; SOT-223-3_TabPin2
U2: ESP32-S3-WROOM

Connections:
+3V3: C1.1, D1.4 (VDD), D2.4 (VDD), D3.4 (VDD), D4.4 (VDD), D5.4 (VDD), D6.4 (VDD), D7.4 (VDD), D8.4 (VDD), J2.1, R3.1, R4.1, RV1.1, RV2.1, U1.2 (VO), U2.2 (VCC)
+5V: J1.A4 (VBUS), J1.A9 (VBUS), U1.3 (VI)
/en: C2.1, J2.2, R3.2, U2.3 (EN)
/enc-1: SW7.A, U2.12 (08|T8|AD1.7)
/enc-2: SW7.B, U2.11 (18|U1RXD|AD2.7)
/flash: J2.3, R4.2, U2.27 (0)
/pix: D1.3 (DIN), U2.10 (17|U1TXD|AD2.6)
/rx: J2.4, U2.36 (44|RX)
/swi1: SW1.1, U2.17 (09|T09|AD1.8|FSPIHD)
/swi2: SW2.1, U2.18 (10|T10|AD1.9|FPSICS0)
/swi3: SW3.1, U2.19 (11|T11|AD2.0|FSPID)
/swi4: SW4.1, U2.20 (12|T12|AD2.1|FSPICLK)
/swi5: SW5.1, U2.21 (13|T13|AD2.2|FSPIQ)
/swi6: SW6.1, U2.39 (01|T01|AD1.0)
/tx: J2.5, U2.37 (43|TX)
/usb+: J1.A6 (D+), J1.B6 (D+), U2.14 (20|U1CTS|AD2.9|USB-D+)
/usb-: J1.A7 (D-), J1.B7 (D-), U2.13 (19|U1RTS|AD2.8|USB-D-)
GND: C1.2, C2.2, D1.2 (VSS), D2.2 (VSS), D3.2 (VSS), D4.2 (VSS), D5.2 (VSS), D6.2 (VSS), D7.2 (VSS), D8.2 (VSS), H1.1, H2.1, J1.A1 (GND), J1.A12 (GND), J1.S1 (SHIELD), J2.6, R1.2, R2.2, RV1.3, RV2.3, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.C, U1.1 (GND), U2.1 (GND), U2.15 (03|T3|AD1.2), U2.40 (GND), U2.41 (GND)
unnamed: D1.1 (DOUT), D2.3 (DIN)
unnamed: D2.1 (DOUT), D3.3 (DIN), D7.3 (DIN)
unnamed: D3.1 (DOUT), D4.3 (DIN), D8.3 (DIN)
unnamed: D4.1 (DOUT), D5.3 (DIN)
unnamed: D5.1 (DOUT), D6.3 (DIN)
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.1
unnamed: RV1.2, U2.4 (04|T4|AD1.3)
unnamed: RV2.2, U2.5 (05|T5|AD1.4)

## KiCad design kicad/5port-headphone-belkin-clone-schnittplatz17./5port-headphone-belkin-clone-schnittplatz17.kicad_pcb

Parts:
IN0: MINIJACK-SMD; 502-35RASMT4BHNTRX
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12: 16; R1206
U$1, U$2, U$3, U$4, U$5: MINIJACK-SMD; 502-35RASMT4BHNTRX

Connections:
GND: IN0.P1, U$1.P1, U$2.P1, U$3.P1, U$4.P1, U$5.P1
unnamed: R1.1, U$1.P3
unnamed: R2.1, U$1.P2
unnamed: R3.1, U$2.P3
unnamed: R4.1, U$2.P2
unnamed: R5.1, U$3.P3
unnamed: R6.1, U$3.P2
unnamed: R7.1, U$4.P3
unnamed: R8.1, U$4.P2
unnamed: R9.1, U$5.P3
unnamed: R10.1, U$5.P2
unnamed: IN0.P3, R11.1
unnamed: IN0.P2, R12.1
unnamed: R1.2, R3.2, R5.2, R7.2, R9.2, R11.2
unnamed: R2.2, R4.2, R6.2, R8.2, R10.2, R12.2

Board: 2 copper layers, 48.6 x 45.1 mm, 20 parts (0 on the bottom side), 15 nets.

Other parts of the board:
@HOLE0, @HOLE1: (no value)
